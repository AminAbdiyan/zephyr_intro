## workspace/boards/custom/nyan/Kconfig.nyan
```kconfig
config BOARD_NYAN
    select SOC_ESP32_WROOM_32UE_N4
    select SOC_ESP32_PROCPU if BOARD_NYAN_ESP32_PROCPU
```
